# Keil uVision project FPLswitch.uvproj, settings and files
target Flash Target (ARM-ADS)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: FPLswitch
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;.\libs\STM32F0xx_StdPeriph_Driver\inc;.\libs\STM32_TouchSensing_Library\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ./src/: system_stm32f0xx.c startup_stm32f051.s
  group main
    ./src/: main.c
  group hal
    ./src/: relay.c util.c
  group std_periph_driver
    ./libs/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c
  group st_touch_library
    ./libs/STM32_TouchSensing_Library/src/: tsl.c tsl_globals.c tsl_acq.c tsl_acq_tsc.c
